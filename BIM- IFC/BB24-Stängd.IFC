Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: O:\Modellprogram\Indoor\Plissé & Duette\BB24\BIM- IFC\BB24-Stängd.IFC
Time: 2026-05-12T12:14:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
